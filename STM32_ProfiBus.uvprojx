# Keil uVision project STM32_ProfiBus.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_ProfiBus
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_XD_VL
  c include: ..\STM32_ProfiBus;.\User;..\..\..\..\..\STM32_Discovery_Kit\STM32VLDiscovery\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\..\STM32_Discovery_Kit\STM32VLDiscovery\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\..\..\STM32_Discovery_Kit\STM32VLDiscovery\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\src;..\..\..\..\..\STM32_Discovery_Kit\STM32VLDiscovery\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc;.\modbus\include;.\modbus\rtu;.\modbus\functions;.\port
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group STM32F1xx_StdPeriph_Driver
    ../../../../../STM32_Discovery_Kit/STM32VLDiscovery/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group Modbus
    ./modbus/: mb.c
    ./modbus/rtu/: mbcrc.c mbrtu.c
    ./modbus/functions/: mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbutils.c
  group Port
    ./port/: portevent.c portserial.c porttimer.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
